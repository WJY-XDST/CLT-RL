# Keil uVision project project_h7.uvprojx, settings and files
target project_h7 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: project_h7 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../cubotMiddleware/Drivers;../support;../cubotMiddleware/Devices;../Usr;../support/ARM/DSP/Include;../support/ARM/DSP/Include/dsp;../support/ARM/DSP/Source/BasicMathFunctions;../support/ARM/DSP/Source/CommonTables;../support/ARM/DSP/Source/FastMathFunctions;../support/ARM/DSP/Source/MatrixFunctions;../support/ARM/DSP/Source/QuaternionMathFunctions;../cubotMiddleware/Devices/BMI088;../cubotMiddleware/Devices/MPU6050;../Usr/Module_task;../Joints;../cubotMiddleware/Algorithms;../control;../cubotMiddleware/Algorithms/Matrix;../control/MRAC
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c i2c.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group user
    ../Usr/: all_init.c
  group driver
    ../support/: linux_list.h
    ../cubotMiddleware/Drivers/: uart_base.c uart_base.h can_base.c can_base.h driver_counter.c driver_spi.c drv_iic.c
  group cubot/devices
    ../cubotMiddleware/Devices/: motor.c DMmotor.c dr16.c HI04.c LK_motor.c et08.c
    ../cubotMiddleware/Devices/BMI088/: bmi088.c ins.c
    ../cubotMiddleware/Devices/MPU6050/: mpu6050.c
    ../Joints/: A1.c A1_stm32.c
  group DSP
    ../support/ARM/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../support/ARM/DSP/Source/CommonTables/: CommonTables.c
    ../support/ARM/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../support/ARM/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../support/ARM/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group cubot/Algorithm
    ../cubotMiddleware/Devices/: user_lib.c
    ../cubotMiddleware/Algorithms/: pid.c kalman_filter.c quaternions_EKF.c filter.c mahony_filter.c
    ../cubotMiddleware/Algorithms/Matrix/: matrix.c
  group module_task
    ../Usr/Module_task/: joint_task.c gyro_task.c chassis_task.c check_task.c observe_task.c stp_task.c can_modify_task.c online_check_task.c
  group Module_Control
    ../control/: rl_host.c rl_host.h additional_con.c torque.c vmc.c WBR.c wheel.c power_con.cpp power_controller.cpp resurgence_control.c
  group MRAC
    ../control/MRAC/: mrac_control.c mrac_control_data.c ert_mrac.c
software components: CMSIS:CORE 4.3.0
